# Repository mairh1/SOUND_HW

## KiCad design CH32L103_SOUND.kicad_pcb

Parts:
BT1: Battery_Cell; Molex_PicoBlade_53048-0210_1x02_P1.25mm_Horizontal
C1, C2, C3: 10UF; C_0402_1005Metric
C4, C5: 1UF; C_0402_1005Metric
C6, C7: 100NF; C_0402_1005Metric
D1: 1N5819WS; D_SOD-323
H1, H2, H3, H4: MountingHole; MountingHole_2.2mm_M2_ISO14580
J1: USB_C_Receptacle_PowerOnly_6P; USB_C_Receptacle_GCT_USB4125-xx-x_6P_TopMnt_Horizontal
J2: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
LED1: RED; LED_0402_1005Metric
LED2: Gree; LED_0402_1005Metric
LED3: LED; LED_0402_1005Metric
LS1: Speaker; Molex_PicoBlade_53048-0210_1x02_P1.25mm_Horizontal
Q1: 2N7002W; SOT-323_SC-70
R1, R2, R9, R15: 10K; R_0402_1005Metric
R3, R4: 5.1K; R_0402_1005Metric
R5: 1.6K; R_0402_1005Metric
R6, R7: 470R; R_0402_1005Metric
R8, R10, R12: 1K; R_0402_1005Metric
R11, R13, R14: 1M; R_0402_1005Metric
SW1: SW_Push; Button_2P
U1: TP4057; TSOT-23-6
U2: HT7533-1; HT7533s
U3: CX588; SOP-8_3.9x4.9mm_P1.27mm
U4: CH32L103F8U6; QFN-20-1EP_3x3mm_P0.4mm_EP1.65x1.65mm
U5: CC6201; SOT-23-3
X1: JYX-0805-C06; C_0805_2012Metric

Connections:
+3.3V: C3.1, C6.2, C7.2, J3.1, R9.2, R10.1, R11.2, R13.2, U2.3 (VOUT), U4.19 (VDD), U5.1 (VIN)
/CC1: J1.A5 (CC1), R4.2
/CC2: J1.B5 (CC2), R3.2
BAT: BT1.1 (+), C2.1, D1.2 (A), U1.3 (BAT), U2.2 (VIN)
BUSY: J2.2, R6.1, U4.7 (PA7)
Dl_POWER: C4.1, D1.1 (K), J2.1, U3.8 (VCC)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.1, C7.1, J1.A12 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.4, J3.2, Q1.2 (S), R3.1, R4.1, R5.2, R8.2, R14.2, R15.1, U1.2 (GND), U2.1 (GND), U3.1 (GND), U4.21 (VSS), U5.3 (GND)
LED1: LED3.1 (K), U4.14 (PA8)
unnamed: LED1.2 (A), R1.2
unnamed: LED1.1 (K), U1.1 (~CHRG)
unnamed: LED2.2 (A), R2.2
unnamed: LED2.1 (K), U1.5 (STDBY)
unnamed: LED3.2 (A), R9.1
unnamed: Q1.1 (G), R12.1, R15.2
unnamed: R8.1, SW1.1
unnamed: R10.2, X1.1
unnamed: R5.1, U1.6 (PROG)
unnamed: R7.2, U3.3 (IO2)
unnamed: R6.2, U3.2 (IO3)
unnamed: LS1.1, SW1.2, U3.5 (SPK1)
unnamed: LS1.2, U3.6 (SPK2)
unnamed: C5.1, U3.7 (VREF)
ONE_Line: J2.3, R7.1, U4.6 (PA5)
PA0: R14.1, U4.1 (PA0/WKUP), X1.2
PA1: Q1.3 (D), R11.1, U4.2 (PA1)
PA6: R13.1, U4.20 (PA6), U5.2 (VOUT)
SWCLK: J3.4, U4.16 (PA14/SWCLK)
SWDIO: J3.3, U4.17 (PA13/SWDIO)
USART1_TX: J3.5, U4.15 (PA9)
VBUS: C1.1, J1.A9 (VBUS), J1.B9 (VBUS), R1.1, R2.1, R12.2, U1.4 (V_{CC})

Notes on the sheet:
霍尔开关
M2螺丝孔
电池充电管理
LED指示灯
震动开关
线性稳压器
CX588语音芯片
CH32L03主控
CH32调试接口
USB-C 6Pin 充电接口
CX588调试接口
充电检测

Board: 2 copper layers, 30.0 x 19.5 mm, 43 parts (0 on the bottom side), 30 nets.

## Commit log

2025-04-29 首次提交
2025-04-30 修改引脚布局
2025-05-04 修改错误丝印
2025-05-12 新增注释
